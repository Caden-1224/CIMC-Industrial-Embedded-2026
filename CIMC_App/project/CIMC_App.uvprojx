# Keil uVision project CIMC_App.uvprojx, settings and files
target CIMC_App (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08011000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: CIMC_App +hex
  AfterMake: fromelf --bin --output .\Objects\CIMC_App.bin .\Objects\CIMC_App.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\CMSIS;..\Startup;..\Library\GD32F4xx_standard_peripheral\Include;..\User;..\CMSIS\GD\GD32F4xx\Include;..\HeaderFiles;..\Function;..\Protocol;..\Driver\LED;..\Driver\KEY;..\Driver\USART;..\Driver\ADC;..\Driver\DAC;..\Driver\GD30AD3344;..\Driver\TIMER;..\Driver\OLED_IIC;..\Driver\SPI_FLASH;..\Driver\InternalFlash;..\Driver\RTC;..\Driver\RS485;..\common;..\Components\ringbuffer
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: gd32f4xx_it.c main.c systick.c
  group Driver
    ../Driver/LED/: LED.c LED.h
    ../Driver/KEY/: KEY.c KEY.h
    ../Driver/USART/: USART.c USART.h usart_dma.c usart_dma.h usart_idle.c usart_idle.h
    ../Driver/ADC/: ADC.c ADC.h
    ../Driver/DAC/: DAC.c DAC.h
    ../Driver/TIMER/: TIMER_BASIC.c TIMER_BASIC.h TIMER_PWM.c TIMER_PWM.h
    ../Driver/OLED_IIC/: OLED_IIC.c OLED_IIC.h OLEDfont.h
    ../Driver/SPI_FLASH/: SPI_FLASH.c SPI_FLASH.h
    ../Driver/InternalFlash/: InternalFlash.c InternalFlash.h
    ../Driver/GD30AD3344/: GD30AD3344.c GD30AD3344.h
    ../Driver/RTC/: RTC.c RTC.h
    ../Driver/RS485/: RS485.c RS485.h rs485_dma.c rs485_dma.h rs485_idle.c rs485_idle.h
  group Protocol
    ../Protocol/: ota_protocol.h cimc_protocol.c cimc_protocol.h ota_protocol.c
  group Function
    ../Function/: Function.c Function.h Led_service.c Led_service.h Key_service.c Key_service.h Usart_service.c Usart_service.h Adc_service.c Adc_service.h Dac_service.c Dac_service.h Gd30ad3344_service.c Gd30ad3344_service.h AutoReport_service.c AutoReport_service.h Alert_service.c Alert_service.h Sleep_service.c Sleep_service.h Oled_service.c Oled_service.h Spi_flash_service.c Spi_flash_service.h BootUpdate_service.c BootUpdate_service.h App_param_service.c App_param_service.h Rtc_service.c Rtc_service.h Rs485_service.c Rs485_service.h
    ../common/: bl_partition.h bl_param.h ota_package_config.h
    ../Components/ringbuffer/: ring_buffer.c ring_buffer.h
  group HeaderFiles
    ../HeaderFiles/: HeaderFiles.h
  group CMSIS
    ../CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group Library
    ../Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group Startup
    ../CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f450_470.s
software components: CMSIS:CORE 5.1.1
